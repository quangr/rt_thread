# Keil uVision project project.uvprojx, settings and files
target HC32F460PETB_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: HC32F460PETB
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_DEVICE_DRIVER_LIB, __CLK_TCK=RT_TICK_PER_SECOND, HC32F460, __RTTHREAD__, __DEBUG, RT_USING_ARM_LIBC
  c misc: --diag_suppress=186,66
  c include: source\myapp;rt-thread\components\net\at\include;rt-thread\components\net\at\at_socket;packages\at24cxx-latest;packages\at_device-v2.0.4\inc;packages\at_device-v2.0.4\class\ec200x;build\DSP\Include;build\DSP\Include\dsp;build\DSP\PrivateInclude;common;rt-thread\components\cplusplus;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;drivers;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;StdDDL\inc;StdDDL\CMSIS;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\none-gcc;source\mqtt\eng\atm;source\mqtt\eng\dev_model;source\mqtt\eng\dev_sign;source\mqtt\eng\infra;source\mqtt\eng\mqtt;source\mqtt\eng\wrappers;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group Applications
    source/myapp/: app_net.c TM1629keyled.c adc_s.c datasetting_s.c tm1650.c mqtt_example_s.c main.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group at_device
    packages/at_device-v2.0.4/class/ec200x/: at_socket_ec200x.c at_device_ec200x.c
    packages/at_device-v2.0.4/src/: at_device.c
    packages/at_device-v2.0.4/samples/: at_sample_ec200x.c
  group CMSIS_dsp
    DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    DSP/Source/SupportFunctions/: SupportFunctions.c
    DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    DSP/Source/TransformFunctions/: TransformFunctions.c
    DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    DSP/Source/CommonTables/: CommonTables.c
    DSP/Source/FastMathFunctions/: FastMathFunctions.c
  group Common
    common/: system_hc32f460petb.c
  group CPlusPlus
    rt-thread/components/cplusplus/: cxx_Thread.cpp cxx_Mutex.cpp crt_init.c cxx_crt.cpp cxx_Semaphore.cpp
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: ringblk_buf.c completion.c workqueue.c dataqueue.c waitqueue.c ringbuffer.c pipe.c
  group Drivers
    board/: board.c
    drivers/: drv_gpio.c drv_ds1302.c drv_soft_i2c.c tm1650.c drv_irq.c drv_usart.c board_config.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_file.c select.c dfs.c poll.c dfs_fs.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group finsh
    rt-thread/components/finsh/: finsh_node.c finsh_parser.c cmd.c finsh_vm.c msh_file.c shell.c msh.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c finsh_init.c
  group HC32_StdPeriph
    StdDDL/src/: hc32f460_utility.c hc32f460_sram.c hc32f460_pwc.c hc32f460_interrupts.c hc32f460_clk.c hc32f460_icg.c hc32f460_dmac.c hc32f460_i2c.c hc32f460_exint_nmi_swi.c hc32f460_timer0.c hc32f460_usart.c hc32f460_efm.c hc32f460_adc.c hc32f460_gpio.c
  group Kernel
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    rt-thread/src/: clock.c object.c ipc.c kservice.c components.c timer.c irq.c thread.c mempool.c mem.c device.c idle.c scheduler.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c syscalls.c mem_std.c stdio.c
    rt-thread/components/libc/compilers/common/: time.c stdlib.c unistd.c delay.c
  group mqtt
    source/mqtt/eng/dev_model/: dm_utils.c dm_ota.c dm_api.c dm_client_adapter.c impl_gateway.c dm_client.c dm_manager.c impl_linkkit.c iotx_cm_mqtt.c dm_opt.c iotx_cm.c dm_message.c impl_ntp.c dm_msg_process.c dm_server_adapter.c dm_tsl_alink.c dm_fota.c dm_server.c dm_shadow.c dm_message_cache.c dm_log_report.c impl_solo.c dm_ipc.c dm_cota.c iotx_cm_coap.c
    source/mqtt/eng/infra/: infra_compat.c infra_cjson.c infra_sha256.c infra_string.c infra_report.c infra_timer.c infra_defs.c infra_prt_nwk_payload.c infra_log.c
    source/mqtt/eng/atm/: at_api.c at_mqtt.c
    source/mqtt/eng/mqtt/: mqtt_api.c
    source/mqtt/eng/dev_sign/: dev_sign_mqtt.c
    source/mqtt/eng/wrappers/4g/: wrapper.c
    source/mqtt/eng/certs/: root_ca.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/impl/: af_inet_at.c
    rt-thread/components/net/sal_socket/socket/: net_sockets.c net_netdb.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
  group startup
    example/MDK/: startup_hc32f460petb.s
target HC32F460PETB_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: as above
  output: HC32F460PETB +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F460
  c misc: --diag_suppress=186,66
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
